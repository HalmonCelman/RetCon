# Repository HalmonCelman/RetCon

File README.md:

# RetCon

Mini Retro Console

Based on LLL language, works on FatFS.
Display: WG12864B1 V1.0-SFYLYHTC06
CPU: Atmega1284p

to run properly LLL( with FatFS ) you need to have at least 3K internal SRAM memory

## Dependencies
- avr-gcc
- avrdude
- cmake

## Build and Run

in program/
```
./configure.sh
./build.sh
./upload.sh
```

*if you are not using usbasp you should change upload.sh*

## Schematic

you can find schematic in `schematic_and_others/schematic` and modify it in KiCAD, or just look below:

## Board and Reality

here are some pictures how the board has been designed and how it looks in reality

## KiCad design schematic_and_others/schematic/RetCon.kicad_pcb

Parts:
BT1: 9V battery; PinSocket_1x02_P2.54mm_Vertical
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1: 330N; C_0805_2012Metric
C2, C3, C5, C8, C9, C10, C11: 100n; C_0805_2012Metric
C4: 2.2u; C_1206_3216Metric
C6, C7: 22p; C_0805_2012Metric
D1: D; C_1206_3216Metric
J1: USB_B_Micro; USBMicro-SMD
J5: PinSocket_1x06_P2.54mm_Vertical
L1: 10uH; L_Bourns-SRN4018
R1: 4K7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3, R4: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RV1: R_Potentiometer; potentiometer10K
SW1: ON/OFF; Button_Switch
SW2: Home; buttonSMD_withHoles
SW3: BumperR; SW_Tactile_SPST_Angled_PTS645Vx31-2LFS
SW4: Select; buttonSMD_withHoles
SW5: BumperL; SW_Tactile_SPST_Angled_PTS645Vx31-2LFS
SW6: TriggerR; SW_Tactile_SPST_Angled_PTS645Vx31-2LFS
SW7: TriggerL; SW_Tactile_SPST_Angled_PTS645Vx31-2LFS
U1: ATmega1284P-A; TQFP-44_10x10mm_P0.8mm
U2: L7805; TO-263-2
U3: WG12864B-STBL; WG12864BL
U4: LF33_TO252; TO-252-2
U5: SN74LS07; SO-14_3.9x8.65mm_P1.27mm
U6: SD; SD_Kyocera_145638009511859+
U7, U8: joystickTHT
Y1: 16Mhz; Crystal_SMD_HC49-SD

Connections:
+3V3: C4.1, R2.1, R3.1, R4.1, U4.3 (VO), U6.4 (VDD)
+5V: C2.1, C3.1, C8.2, C9.2, C10.2, J1.1 (VBUS), J5.5, L1.1, R1.1, RV1.3, U1.5 (VCC), U1.17 (VCC), U1.38 (VCC), U2.3 (OUT), U3.4 (Vdd), U3.17 (RST), U3.19 (Anode), U4.1 (VI), U5.14 (VCC), U7.1 (P11), U7.6 (P23), U8.1 (P11), U8.6 (P23); also elsewhere on the board
/BumperL: SW5.2, U1.11 (PD2)
/BumperR: SW3.1, U1.32 (PA5)
/CS: U1.44 (PB4), U5.1
/Home: SW2.2, U1.9 (PD0)
/LAnalogX: U1.37 (PA0), U7.5 (P22)
/LAnalogY: U1.36 (PA1), U7.2 (P12)
/LCD_CS1: U1.12 (PD3), U3.1 (CS1)
/LCD_CS2: U1.13 (PD4), U3.2 (CS2)
/LCD_DATA0: U1.19 (PC0), U3.9 (DB0)
/LCD_DATA1: U1.20 (PC1), U3.10 (DB1)
/LCD_DATA2: U1.21 (PC2), U3.11 (DB2)
/LCD_DATA3: U1.22 (PC3), U3.12 (DB3)
/LCD_DATA4: U1.23 (PC4), U3.13 (DB4)
/LCD_DATA5: U1.24 (PC5), U3.14 (DB5)
/LCD_DATA6: U1.25 (PC6), U3.15 (DB6)
/LCD_DATA7: U1.26 (PC7), U3.16 (DB7)
/LCD_E: U1.16 (PD7), U3.8 (E)
/LCD_RS: U1.14 (PD5), U3.6 (RS)
/LCD_RST: U1.15 (PD6), U3.7 (RW)
/MISO: J5.2, R1.2, U1.2 (PB6), U5.8
/MOSI: J5.1, U1.1 (PB5), U5.3
/RAnalogX: U1.35 (PA2), U8.5 (P22)
/RAnalogY: U1.34 (PA3), U8.2 (P12)
/RST: J5.4, U1.4 (~RESET)
/SCK: J5.3, U1.3 (PB7), U5.5
/Select: SW4.2, U1.42 (PB2)
/TriggerL: SW7.2, U1.10 (PD1)
/TriggerR: SW6.1, U1.33 (PA4)
GND: BT1.2 (-), BZ1.2 (+), C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, J1.5 (GND), J1.6 (Shield), J5.6, SW2.1, SW3.2, SW4.1, SW5.1, SW6.2, SW7.1, U1.6 (GND), U1.18 (GND), U1.28 (GND), U1.39 (GND), U2.2 (GND), U3.3 (Vss), U3.20 (Kathode), U4.2 (GND), U5.7 (GND), U6.3 (VSS), U6.6 (VSS), U7.3 (P13), U7.4 (P21), U8.3 (P13), U8.4 (P21); also elsewhere on the board
unnamed: BT1.1 (+), SW1.1 (A)
unnamed: BZ1.1 (-), U1.43 (PB3)
unnamed: D1.2 (A), SW1.2 (B)
unnamed: C1.1, D1.1 (K), U2.1 (IN)
unnamed: C5.2, U1.29 (AREF)
unnamed: C11.2, L1.2, U1.27 (AVCC)
unnamed: C6.2, U1.8 (XTAL1), Y1.1
unnamed: C7.2, U1.7 (XTAL2), Y1.2
unnamed: RV1.2, U3.5 (V0)
unnamed: RV1.1, U3.18 (VEE)
unnamed: R2.2, U5.2, U6.1 (CD/DAT3)
unnamed: R4.2, U5.6, U6.5 (CLK)
unnamed: R3.2, U5.4, U6.2 (CMD)
unnamed: U5.9, U6.7 (DAT0)

Notes on the sheet:
mcu and lcd display
inputs
power supply
programming port
memory
rest of sn74ls07 connections

Board: 2 copper layers, 139.5 x 70.4 mm, 42 parts (30 on the bottom side), 45 nets.

Other parts of the board:
J1#2: USB_B_Micro; USBMicro-SMD
J2: Hole2; One_hole
J3: Hole3; One_hole
J4: Hole4; One_hole

Their connections:
+5V: J1#2.1 (VBUS); also elsewhere on the board
GND: J1#2.5 (GND), J1#2.6 (Shield); also elsewhere on the board

## KiCad design schemat_i_inne/schemat/adapter/adapter/adapter.kicad_pcb

Parts:
C1: C; PinHeader_1x02_P2.54mm_Vertical
J1: Conn_01x06_Female; PinHeader_1x06_P2.54mm_Vertical
J2: RJ45; RJ45_Amphenol_54602-x08_Horizontal

Connections:
unnamed: C1.1, J1.1, J2.1
unnamed: C1.2, J1.2, J2.2
unnamed: J1.3, J2.5
unnamed: J1.4, J2.6
unnamed: J1.5, J2.7
unnamed: J1.6, J2.8

Board: 2 copper layers, 186.7 x 274.3 mm, 3 parts (3 on the bottom side), 6 nets.

## KiCad design schemat_i_inne/schemat/konwerter/karta+konwerter/konwerter.kicad_pcb

Parts:
C1, C2: 100N; PinHeader_1x02_P2.54mm_Vertical
J1: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Vertical
R1, R2, R3, R4: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1, U3, U4, U5: IRF7476; PowerIntegrations_SO-8
U2: LM1117-1.8; SOT-223-3_TabPin2
U6: SD; SD_Kyocera_145638009511859+

Connections:
+1V8: C2.1, R1.1, R3.1, R4.1, U2.2 (VO), U5.4 (G), U6.3, U6.6
+5V: C1.1, J1.1, U2.3 (VI), U6.4
/CS: J1.2, U4.1 (S), U4.2 (S), U4.3 (S)
/MISO: J1.5, R2.1, U5.5 (D), U5.6 (D), U5.7 (D), U5.8 (D)
/MOSI: J1.3, U1.1 (S), U1.2 (S), U1.3 (S)
/SCK: J1.4, U3.1 (S), U3.2 (S), U3.3 (S)
GND: C1.2, C2.2, J1.6, R2.2, U1.4 (G), U2.1 (GND), U3.4 (G), U4.4 (G)
unnamed: R1.2, U1.5 (D), U1.6 (D), U1.7 (D), U1.8 (D), U6.2
unnamed: R3.2, U3.5 (D), U3.6 (D), U3.7 (D), U3.8 (D), U6.5
unnamed: R4.2, U4.5 (D), U4.6 (D), U4.7 (D), U4.8 (D), U6.1
unnamed: U5.1 (S), U5.2 (S), U5.3 (S), U6.7

Notes on the sheet:
+5V
GND
Stabilizacja 1,8V

Board: 2 copper layers, 269.2 x 182.9 mm, 13 parts (3 on the bottom side), 11 nets.

## Commit log

2022-04-18 Pierwszy commit
    Kod z innego projektu( KoKOS mini games )
2022-04-19 Menu ukonczone
    Duzo zmian nowych funkcji i ukonczenie menu
2022-04-21 Spaghetti dodane
    Dodano przyciski do spaghetti układu
2022-04-25 Kupa roboty
    Wstepna plytka PCB zaprojektowana dla niebieskiego ekranu, 1 opornik 0R THT
2022-04-26 Dodano rrator i animacje rozbita na klatki
    Rrator to napisany przeze mnie program do zmieniania nazw
2022-04-29 Exportator, wyswietlanie i inne
    Dodano exportator, zmieniono tablice z 8x128 na 1024
    i dodano ubogie wyswietlanie animacji
    TODO: animacje porzadnie i kwarc na schemat
2022-04-30 Schemat, scalenie i porzadki
    ->Zaktualizowano schemat
    ->Dodano skrypt manima.sh scalajacy poprzednie
    ->Dodano instrukcje tworzenia animacji
2022-04-30 Aktualizacja README
    Zeby jakos wygladalo
2022-05-01 Odcinek 1 z serii co tu sie kurka stalo
    Delay sprawia ze animacja dziala XD nie wazne jaka wartosc
2022-05-05 Commit zeby nie stracic progresu
2022-05-09 Zmieniono uklad symboli na plytce
2022-05-09 Dodane polaczenia
    Dodano wszystkie polaczenia
2022-05-09 Lepsze sciezki, wypelnione GND
2022-05-09 Buzzer
    Dodano buzzer
2022-05-12 Kolejne zmiany w szchemacie i plytce
    ->Dodano gniazdo ethernetowe i adapter zamiast zlacza 6pin
    aby byla mozliwa komunikacja miedzy konsolami
    ->zmieniono rozmieszczenie przyciskow
    ->drobne poprawki sciezek
2022-05-21 Upraszczanie polaczen i poprawianie plytki
    Gotowe polaczenia do ekranu
2022-05-24 Wiele elementow dodanych
2022-05-27 Wszystkie polaczenia
    Zrealizowano wszystkie polaczenia, wygaldaja okropnie ale sa XD
2022-05-27 Awful, but should work XD
    Strasznie brzydko, wszystkie sciezki do poprawy graficznej.
    Zamieniono przyciski tak aby były w dobrych miejscach
2022-05-28 Strefy i poprawki
    Dodano strefe GND i poprawiono juz czesc sciezek
2022-05-29 Koncowe sciezki i adapter
    Ukonczono poprawianie sciezek i poprawnie zrobiono adapter
2022-05-30 Logo i wymiary
    Dodano "by KK" i wymiary plyty glownej
2022-06-02 karta zle -sadge
2022-06-02 New branch konwerter started
2022-06-07 Konwerter na mosfetach
2022-06-07 Poprawiony wyglad konwertera
2022-06-09 Gotowa plytka karty z konwerterem
2022-08-06 Konwerter update
    -> Poprawiony schemat konwertera
    -> Samodzielna płytka z konwerterem
    -> poprawiony symbol karty aby pasował do footprintu
2022-08-06 Dodano "by KK"
2022-08-11 Dodano schemat do adaptera karty
    -> wyprowadzenie waznych pinow karty jako 6 pinowe zlacze
2022-08-12 Dodano plytke karty
2022-08-13 Dodano by KK i przygotowano do produkcji
2022-09-11 New version of KiCAD
2022-09-14 Kolejna zmiana konwertera
    -> poprzedni konwerter dzialal, ale nie wzialem
    pod uwage droputu na MOSFETach, wiec poziomy logiczne i tak
    sie nie zgadzaly
    -> zmieniony konwerter z gotowa plytka, dzialajacy juz na
    normalnych zasadach
2022-09-21 Uzupelniony schemat niebieskiego
    -> dodano bufor i zastosowano konwersje napiec
    -> poprawiono symbol karty SD
    -> zapisano w formacie KiCAD 6.0
2022-09-21 Good footprints, before changes on PCB
2022-09-21 Wstepne sciezki z buforem
    -> Dodano wstepne sciezki razem z buforem
    -> Tam gdzie bylo to wymagane zmieniono warstwe
    -> Dodano oporniki 0R we wlasciwych miejscach
2022-09-22 Awful but should work v2
    -> Wszystko zostalo prowizorycznie podlaczone
    -> uzyto 3 opornikow 0R
2022-09-25 Not all connections, but better positions
2022-09-29 Ukonczone polaczenia
    -> skonczone polaczenia poprawionego schematu
    po przeniesieniu karty
2022-10-03 Little changes
    -> nic waznego, troche porzadkow
2022-10-06 Bardzo drobna zmiana plytki
    -> Wyrownano dw gorne skrajne otwory
2022-10-23 changed from m32 to m1284p -> for future FatFS
2022-11-04 Working board -> Atmega 1284p -> PetitFS -> SPI2X enabled -> !WARNING! key connected to PB4 resets MSTR bit in SPI configuration, in future should be moved to another pin
2022-11-04 PetitFS changed to FatFS -> still no f_write -> working even faster than petit -> use around 2K RAM -> can open multiple files at once
2022-11-15 Working f_write() and FatFS
    -> corrected bug: disk_timerproc() has been working 25x too fast
    and that was cause of f_write 1 error
    -> delay timing corrected( delay has been working 2,5x too fast )
2022-11-16 Exportator restored, and scripts to make animation corrected -> some changes also in rrator: prename instead of rename due to system change
2022-11-16 Added section issues and README modificated
2022-11-24 Updated PCB ->key isn't anymore on PB4
2022-11-29 Some work on LLKL
2022-11-30 LLKL description( not completed )
    -> based on assembly LLKL
    -> 18 instruction added
    -> memory description added
2022-12-01 LLKL description completed
    -> added some commands
    -> added labels
2022-12-05 LLKL, RetCon desription -> Better LLKL description -> RetCon streams description -> First example program added
2022-12-05 Updated LLKL description and implementation -> CP and CPI changed -> SERI has been implemented -> Debug mode added -> Part of memory management added
2022-12-07 Logs added -> last log is displayed at the screen -> all logs are in LOG.txt file -> next step is to support LFN
2022-12-09 LL functions and description
    -> Added to llkl description what is returned
    when llkl reach end of program
    -> Added pointers structure, programs now can be very long
    -> Added "multifiling" - many files used at once
    Described in low level header
    -> Added init and end program functions
2022-12-12 llkl get -> fully implemented llkl_get -> still one issue exist but it's not important
2022-12-12 Custom Makefile added
    -> Changed from CodeBlocks to custom makefile
    -> This Makefile is universal makefile for avr
2022-12-13 Working seri() -> seri() is now working well -> better memory -> added actual log file from uno.txt to llkl examples
2022-12-17 Aby nie stracic zmian -> zmiana systemu operacyjnego
2022-12-19 Changed gcc to version 12
    -> due to gcc change, extern has to be used many times...
2023-05-24 Better schema
    -> prevented reversed voltage
    -> added switch to select voltage source (external/internal)
    -> looks very unclear, needs correct
2023-07-20 Working CMake build and upload
    use following comands
    ./configure.sh
    ./build.sh
    ./upload.sh
2023-07-21 Cleaning
    - created modules
    - updated structure of files
2023-07-24 Debug Mode - Debug Mode configuring from CMake - better varialibes names - some troubleshooting
2023-07-25 Running main program
    - created new functiion in LLKL - LLKL_run()
2023-07-25 External memory and LFN
    - external memory functions added and updated
    - LFN tried to add but linker error occured
2023-07-26 Cache, slow memory and 8.3 standard
    - names of files according to 8.3 standard(SFN)
    - now folder for Cache is created at start and deleted at end
    - slow memory still don't work at all - invalid object
2023-07-27 Working slow memory
2023-07-27 Better memory placement
    - flags at start
    - slow and fast memory one after another
2023-07-27 with deleting cache
2023-07-27 Labels added
    - label working requires verification
2023-07-27 working labels
2023-07-27 Changed assumptions of LLKL
    - fewer commands
    - no signed ints
2023-07-29 SERI updated
    - multiple INTs to registers
2023-07-29 Add function added
2023-07-30 Addi, Out and streams added
2023-08-01 LLKL name and first compiler
    - changed name to LLL
    - first compiler added
2023-08-02 LLKL name changed to LLL
    - also corrected add and addi
2023-08-02 Deleted LLL being not submodule
2023-08-02 Added LLL as a submodule
2023-08-02 Added automatic submodules update
2023-08-03 Cosmetic changes
    - nothing important, executing all avialibe examples of llkl
2023-08-04 new functions testing
    - div,divi
    - and,andi
    - or,ori
    - not,inc,dec
2023-08-05 getPosition and goTo added in LLL driver
2023-08-05 Added examples fo ret and ljmp
2023-08-08 new functions in llkl
    - additional initialization
2023-08-09 Streams corrected, writing on screen
    - now you can have normal log file without drawing on screen
2023-08-09 In stream added
    - setTimer and getTimer
2023-08-11 New function and streams update - new function in multibuff - fillRect - fillRect and strokeRect in streams
2023-08-12 Forward labels added
2023-08-23 new version of schema and board
2023-08-24 Complete board, DRC test passed
2023-08-24 better descriptive layer, and logo added
2023-11-07 Footprint for joysticks corrected
2023-11-08 More footprints updated - buttons - USB micro - coil
2023-11-23 Fully updated PCB of RetCon
    - It is in schemat/Niebieski folder
    - First checkout of parts has been done
2023-12-01 Board Completed
    - sent to production
2023-12-05 LICENSE Added
2023-12-30 New board connections inside program
2023-12-30 Working lll on RetCon
    - still some errors during conversion in lll_send_info
    - external memory still isn't implemented
2024-02-15 Streams update
    - some streams added
    - working "running square"
2024-02-25 Streams execution mapped
    - stream functions are mapped
    - new streams described
    - writeChar stream fixed
2024-02-26 RetCon config file and small updates
    - names of triggers and bumpers updated
    - schematic, board updated
    - added picture how RetCon looks in reality
2024-02-26 Delay and Beep streams implemented
2024-02-27 Changed names, improved initialization
2024-02-28 Buttons stream
    - board to fix: shortcuts between pins
2024-03-05 FatFs refactoring
2024-03-05 Refactoring completed
2024-03-05 FatFs as submodule
2024-04-20 Better schematic
    - fixed mistake of connecting buttons to +5V
    - clearer schematic
    - PCB to update
2024-04-21 Board update
    - capacitors placed and connected
    - buttons connected to ground
    - need to update buttons and display footprints
2024-04-25 Board sent to manufacturer
2024-05-10 ADC working
    - joysticks still seems to have issues in X axis
